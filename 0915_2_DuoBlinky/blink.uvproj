# Keil uVision project blink.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F350 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x1FFF) CLOCK(50000000)
  output: blink +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 C8051F350.h Duoblinky.c
